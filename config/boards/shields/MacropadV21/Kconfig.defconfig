## config/boards/shields/MacropadV21/Kconfig.defconfig
```kconfig
if SHIELD_MACROPADV21

config ZMK_KEYBOARD_NAME
    default "MacropadV21"
ZMK_STUDIO=y
endif
```
